# Keil uVision project pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: pro +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: STARTUP.A51
    ../user/: main.c
  group user
    ../user/: key.c lcd.c motor.c ds1302.c temp.c ir.c i2c.c eeprom.c gui.c lcd_driver.c XPT2046.c
  group read me
    ../user/: read me.txt
